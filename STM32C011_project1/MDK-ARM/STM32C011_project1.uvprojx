# Keil uVision project STM32C011_project1.uvprojx, settings and files
target STM32C011_project1 (6180000::V6.18::ARMCLANG)
  device: STM32C011F4Px STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8003FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32C011_project1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C011xx
  c include: ../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32c011xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
software components: CMSIS:CORE 4.3.0
